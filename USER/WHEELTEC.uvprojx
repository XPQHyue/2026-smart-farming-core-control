# Keil uVision project WHEELTEC.uvprojx, settings and files
target WHEELTEC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WHEELTEC +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\SYSTEM\Inc;..\WHEELTEC_BSP\Inc;..\USER;..\WHEELTEC_BSP\VL53L0X\core\inc;..\WHEELTEC_BSP\VL53L0X\demo;..\WHEELTEC_BSP\VL53L0X\platform\inc;..\WHEELTEC_BSP\WIT_SDK
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_pwr.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group WHEELTEC_BSP
    ../WHEELTEC_BSP/: bsp_led.c bsp_oled.c bsp_siic.c bsp_icm20948.c bsp_tim.c bsp_adc.c bsp_key.c bsp_buzzer.c bsp_motor.c bsp_encoder.c bsp_usart.c pid_study.c robot_state.c bsp_bluetooth.c bsp_vl53l0x.c gpio_inout.c
    ../WHEELTEC_BSP/Inc/: robot_state.h
  group VL53L0X
    ../WHEELTEC_BSP/VL53L0X/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
    ../WHEELTEC_BSP/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../WHEELTEC_BSP/VL53L0X/demo/: vl53l0x.c vl53l0x_it.c vl53l0x_gen.c
  group WIT_SDK
    ../WHEELTEC_BSP/WIT_SDK/: wit_c_sdk.c bsp_wit_uart4.c
